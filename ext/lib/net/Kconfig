## ext/lib/net/knot/Kconfig
```kconfig
config KNOT
	bool
	prompt "KNOT Support"
	help
	  This option enables the KNOT library.
```
